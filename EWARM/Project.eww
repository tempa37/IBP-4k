<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\IBP-4k.ewp</path>
  </project>
  <batchBuild />
</workspace>
